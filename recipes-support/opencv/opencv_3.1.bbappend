FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-Fix-recognition-confidence-prediction.patch;patchdir=../contrib "
